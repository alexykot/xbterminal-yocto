EXTRA_OECONF_append = " --enable-unicode=ucs4"
