DESCRIPTION = "Python Serial Port Extension"
HOMEPAGE = "http://pyserial.readthedocs.io/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=d476d94926db6e0008a5b3860d1f5c0d"

PR = "r0"

SRC_URI[md5sum] = "e849af7f8b7ec75cbc7a53da67c51a51"
SRC_URI[sha256sum] = "c8ffdcbd8bfd308842409e558848c32aa3499a1bfe95a591e4210072b9520f1e"

inherit pypi setuptools

PYPI_PACKAGE_HASH = "ce9c694ce79a9d4a164e109aeba1a40fba23336f3b7554978553e22a5d41d54d"
