require python-cryptography.inc

PR = "r0"

SRC_URI[md5sum] = "fade66de437392ed1ba6980768626204"
SRC_URI[sha256sum] = "878cb68b3da3d493ffd68f36db11c29deee623671d3287c3f8d685117ffda9a9"

PYPI_PACKAGE_HASH = "99df71c7260003f5c469cec3db4c547115df39e9ce6c719a99e067ba0e78fd8a"
