RDEPENDS_${PN} += " icu"
