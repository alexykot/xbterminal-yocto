DESCRIPTION = "Python package for providing Mozilla's CA Bundle."
HOMEPAGE = "http://certifi.io/"
LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f77f61d14ee6feac4228d3ebd26cc1f1"

PR = "r0"

SRC_URI[md5sum] = "5d672aa766e1f773c75cfeccd02d3650"
SRC_URI[sha256sum] = "5e8eccf95924658c97b990b50552addb64f55e1e3dfe4880456ac1f287dc79d0"

inherit pypi

PYPI_PACKAGE_HASH = "5cf8f6c54727c74579c6bbe5926f5deb9677c5810a33e11da58d1a4e2d09d041"

