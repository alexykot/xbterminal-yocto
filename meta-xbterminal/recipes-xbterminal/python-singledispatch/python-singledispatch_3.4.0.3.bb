DESCRIPTION = "This library brings functools.singledispatch from Python 3.4 to Python 2.6-3.3."
HOMEPAGE = "https://docs.python.org/3/library/functools.html#functools.singledispatch"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://setup.py;beginline=6;endline=25;md5=4422e8a35b019769f838669b6f30db85"

PR = "r0"

SRC_URI[md5sum] = "af2fc6a3d6cc5a02d0bf54d909785fcb"
SRC_URI[sha256sum] = "5b06af87df13818d14f08a028e42f566640aef80805c3b50c5056b086e3c2b9c"

inherit pypi

PYPI_PACKAGE_HASH = "d9e9513ad8dc17210db12cb14f2d4d190d618fb87dd38814203ea71c87ba5b68"
