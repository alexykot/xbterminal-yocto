FILESEXTRAPATHS_append := ":${THISDIR}/files"
SRC_URI += "file://fix_config_wandboard_mmcargs.patch"
